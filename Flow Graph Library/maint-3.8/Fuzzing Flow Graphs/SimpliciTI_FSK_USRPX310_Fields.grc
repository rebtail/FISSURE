options:
  parameters:
    category: Custom
    generate_options: no_gui
    id: SimpliciTI_FSK_USRPX310_Fields
    output_language: python
  states: {}

blocks:
- name: data_rate
  id: variable
  parameters:
    value: '2398.9677429'
  states: {}
- name: filepath
  id: variable
  parameters:
    value: '"/home/user/FISSURE/Flow Graph Library/Single-Stage Flow Graphs/Attack Files/SimpliciTI_Add_Node2.bin"'
  states: {}
- name: fuzzing_data
  id: variable
  parameters:
    value: '"0"'
  states: {}
- name: fuzzing_fields
  id: variable
  parameters:
    value: '"[''Temperature LSB'',''Voltage'']"'
  states: {}
- name: fuzzing_interval
  id: variable
  parameters:
    value: '"1"'
  states: {}
- name: fuzzing_max
  id: variable
  parameters:
    value: '"[''255'',''255'']"'
  states: {}
- name: fuzzing_min
  id: variable
  parameters:
    value: '"[''0'',''0'']"'
  states: {}
- name: fuzzing_packet_type
  id: variable
  parameters:
    value: '"ED-Data"'
  states: {}
- name: fuzzing_protocol
  id: variable
  parameters:
    value: '"SimpliciTI"'
  states: {}
- name: fuzzing_seed
  id: variable
  parameters:
    value: '"0"'
  states: {}
- name: fuzzing_type
  id: variable
  parameters:
    value: '"[''Random'',''Sequential'']"'
  states: {}
- name: ip_address
  id: variable
  parameters:
    value: '"192.168.40.2"'
  states: {}
- name: library_filepath
  id: variable
  parameters:
    value: '"~/FISSURE/YAML/library_3_8.yaml"'
  states: {}
- name: sample_rate
  id: variable
  parameters:
    value: 4e6
  states: {}
- name: sampling_factor
  id: variable
  parameters:
    value: '100'
  states: {}
- name: sampling_multiple
  id: variable
  parameters:
    value: '16'
  states: {}
- name: tx_frequency
  id: variable
  parameters:
    value: 2425.715e6
  states: {}
- name: tx_usrp_antenna
  id: variable
  parameters:
    value: '"TX/RX"'
  states: {}
- name: tx_usrp_channel
  id: variable
  parameters:
    value: '"A:0"'
  states: {}
- name: tx_usrp_gain
  id: variable
  parameters:
    value: '30'
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_float_to_char_0
  id: blocks_float_to_char
  parameters:
    scale: '1'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.1'
    type: complex
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: byte
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: digital_gfsk_mod_0
  id: digital_gfsk_mod
  parameters:
    bt: '0.5'
    samples_per_symbol: '200'
    sensitivity: '0.1'
  states: {}
- name: fuzzer_fuzzer_0
  id: fuzzer_fuzzer
  parameters:
    fuzzing_data: fuzzing_data
    fuzzing_fields: fuzzing_fields
    fuzzing_interval: fuzzing_interval
    fuzzing_max: fuzzing_max
    fuzzing_min: fuzzing_min
    fuzzing_packet_type: fuzzing_packet_type
    fuzzing_protocol: fuzzing_protocol
    fuzzing_seed: fuzzing_seed
    fuzzing_type: fuzzing_type
    library_filepath: library_filepath
  states: {}
- name: fuzzer_packet_insert_0
  id: fuzzer_packet_insert
  parameters:
    offset: '0'
    period: '20'
    vector: '0'
  states: {}
- name: mmse_resampler_xx_0
  id: mmse_resampler_xx
  parameters:
    phase_shift: '0'
    resamp_ratio: sampling_factor*data_rate*sampling_multiple/sample_rate
    type: complex
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: tx_usrp_antenna
    center_freq0: tx_frequency
    clock_rate: '0.0'
    dev_args: '"addr=" + ip_address'
    gain0: tx_usrp_gain
    len_tag_name: ''
    norm_gain0: 'False'
    samp_rate: sample_rate
    sd_spec0: tx_usrp_channel
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_sink_0_0
  id: uhd_usrp_sink
  parameters:
    ant0: tx_usrp_antenna
    center_freq0: tx_frequency
    clock_rate: '0.0'
    gain0: tx_usrp_gain
    len_tag_name: ''
    norm_gain0: 'False'
    samp_rate: sample_rate
    sd_spec0: '"A:A"'
    sync: sync
    type: fc32
  states: {state: disabled}

connections:
- [blocks_char_to_float_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_float_to_char_0, '0', digital_gfsk_mod_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_float_to_char_0, '0']
- [blocks_multiply_const_vxx_1, '0', uhd_usrp_sink_0, '0']
- [blocks_multiply_const_vxx_1, '0', uhd_usrp_sink_0_0, '0']
- [blocks_null_source_0, '0', fuzzer_packet_insert_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_char_to_float_0, '0']
- [digital_gfsk_mod_0, '0', mmse_resampler_xx_0, '0']
- [fuzzer_fuzzer_0, packet_out, fuzzer_packet_insert_0, packet_in]
- [fuzzer_packet_insert_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [mmse_resampler_xx_0, '0', blocks_multiply_const_vxx_1, '0']

metadata:
  file_format: 1
